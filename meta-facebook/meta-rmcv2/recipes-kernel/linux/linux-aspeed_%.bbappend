FILESEXTRAPATHS:prepend := "${THISDIR}/linux-aspeed:"

SRC_URI += " \
    file://0001-ARM-dts-aspeed-rmcv2-Add-Meta-rmcv2-BMC.patch \
"
